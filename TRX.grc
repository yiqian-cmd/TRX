options:
  parameters:
    author: RMUC2026-NC
    category: '[RMUC2026-NC]'
    description: 'Full-wave single-NanoSDR loopback. TX: ZMQ(53101) -> 4 parallel GFSK modulators (info 540kHz@1.5628, int1 940kHz@2.8194, int2 860kHz@2.5681, int3 250kHz@0.6517) with web-controlled gates -> 4-input add -> Pluto Sink. RX: Pluto Source -> dual NCO branches: interfere branch (auto-adapting bw/gain via rx_int_bw) -> ZMQ 53104, info branch (540kHz) -> ZMQ 53103. XMLRPC server on 53106.'
    generate_options: qt_gui
    id: TRX
    output_language: python
    title: TRX 全波形收发回环 - 单台Pluto (信息波+红方1/2/3级干扰波+第二源信息波)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 采样率 1 MHz
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: 每符号采样数
    value: '47'
  states: {}
- name: bt
  id: variable
  parameters:
    comment: GFSK BT
    value: '0.35'
  states: {}
- name: bw
  id: variable
  parameters:
    comment: Pluto 模拟射频带宽
    value: '1000000'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    comment: 符号同步环带宽
    value: '0.005'
  states: {}
- name: Time_Sink_Number
  id: variable
  parameters:
    value: '200'
  states: {}
- name: sdr_uri1
  id: variable
  parameters:
    comment: 本机 SDR 的 IP（按实际修改）
    value: '''ip:192.168.2.1'''
  states: {}
- name: info_bw
  id: variable
  parameters:
    comment: 信息波带宽(规则表5-23)
    value: '540000'
  states: {}
- name: int1_bw
  id: variable
  parameters:
    comment: 红方1级干扰带宽
    value: '940000'
  states: {}
- name: int2_bw
  id: variable
  parameters:
    comment: 红方2级干扰带宽
    value: '860000'
  states: {}
- name: int3_bw
  id: variable
  parameters:
    comment: 红方3级干扰带宽
    value: '250000'
  states: {}
- name: rx_info_bw
  id: variable
  parameters:
    comment: 信息支路带宽
    value: '540000'
  states: {}
- name: rx_int_fir_taps
  id: variable
  parameters:
    comment: 干扰支路信道滤波抽头(自适应)
    value: firdes.low_pass(1, samp_rate, rx_int_bw / 2, 20000)
  states: {}
- name: rx_info_fir_taps
  id: variable
  parameters:
    comment: 信息支路信道滤波抽头
    value: firdes.low_pass(1, samp_rate, rx_info_bw / 2, 20000)
  states: {}
- name: tx_center_freq1
  id: variable
  parameters:
    comment: 主发射频点(随网页波形自动切换) [XMLRPC 同步]
    value: '432200000'
  states: {}
- name: tx_center_freq2
  id: variable
  parameters:
    comment: 第二发射频点(本图未用第二发射) [XMLRPC 同步]
    value: '433200000'
  states: {}
- name: tx_attenuation1
  id: variable
  parameters:
    comment: 主发射衰减 dB [XMLRPC 同步]
    value: '10'
  states: {}
- name: tx_attenuation2
  id: variable
  parameters:
    comment: 第二发射衰减 dB [XMLRPC 同步]
    value: '60'
  states: {}
- name: tx_mod_info_en
  id: variable
  parameters:
    comment: 信息波门控 [XMLRPC 同步]
    value: '0.0'
  states: {}
- name: tx_mod_int1_en
  id: variable
  parameters:
    comment: 1级干扰门控 [XMLRPC 同步]
    value: '1.0'
  states: {}
- name: tx_mod_int2_en
  id: variable
  parameters:
    comment: 2级干扰门控 [XMLRPC 同步]
    value: '0.0'
  states: {}
- name: tx_mod_int3_en
  id: variable
  parameters:
    comment: 3级干扰门控 [XMLRPC 同步]
    value: '0.0'
  states: {}
- name: rx_center_freq
  id: variable
  parameters:
    comment: RX 中心频点 [XMLRPC 同步]
    value: '432200000'
  states: {}
- name: rx_interfere_channel_freq
  id: variable
  parameters:
    comment: 干扰支路频点 [XMLRPC 同步]
    value: '432200000'
  states: {}
- name: rx_info_channel_freq
  id: variable
  parameters:
    comment: 信息支路频点 [XMLRPC 同步]
    value: '433200000'
  states: {}
- name: rx_int_bw
  id: variable
  parameters:
    comment: 当前干扰等级带宽 [XMLRPC 同步]
    value: '940000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: RX 手动增益 [XMLRPC 同步]
    value: '40'
  states: {}
- name: zmq_bits_in
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:53101
    comment: Python TxWorker packed bytes
    timeout: '100'
    type: byte
  states: {}
- name: zmq_bits_in_2nd
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:53102
    comment: 第二发射源信息波 packed bytes (网页启用后才发流)
    timeout: '100'
    type: byte
  states: {}
- name: tx_mod_info_2nd
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: 第二发射源信息波 GFSK(固定信息波)
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((info_bw/2)-(samp_rate/sps))/samp_rate
  states: {}
- name: tx_mod_info
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: 信息波 GFSK, sens≈1.5628
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((info_bw/2)-(samp_rate/sps))/samp_rate
  states: {}
- name: tx_mod_int1
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: 1级干扰 GFSK, sens≈2.8194
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((int1_bw/2)-(samp_rate/sps))/samp_rate
  states: {}
- name: tx_mod_int2
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: 2级干扰 GFSK, sens≈2.5681
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((int2_bw/2)-(samp_rate/sps))/samp_rate
  states: {}
- name: tx_mod_int3
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: 3级干扰 GFSK, sens≈0.6517
    samples_per_symbol: sps
    sensitivity: 2*3.141592653589793*((int3_bw/2)-(samp_rate/sps))/samp_rate
  states: {}
- name: tx_mod_info_gate
  id: blocks_multiply_const_vxx
  parameters:
    comment: 信息波门控
    const: tx_mod_info_en
    type: complex
  states: {}
- name: tx_mod_int1_gate
  id: blocks_multiply_const_vxx
  parameters:
    comment: 1级门控
    const: tx_mod_int1_en
    type: complex
  states: {}
- name: tx_mod_int2_gate
  id: blocks_multiply_const_vxx
  parameters:
    comment: 2级门控
    const: tx_mod_int2_en
    type: complex
  states: {}
- name: tx_mod_int3_gate
  id: blocks_multiply_const_vxx
  parameters:
    comment: 3级门控
    const: tx_mod_int3_en
    type: complex
  states: {}
- name: tx_wave_add
  id: blocks_add_xx
  parameters:
    comment: 四路门控波形+第二源信息波 叠加
    num_inputs: '5'
    type: complex
  states: {}
- name: nanosdr_sink
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation1
    bandwidth: samp_rate
    buffer_size: '32768'
    comment: 'Pluto 发射: 频点/衰减由 XMLRPC 实时控制'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_center_freq1
    samplerate: samp_rate
    type: fc32
    uri: sdr_uri1
  states: {}
- name: xmlrpc_server
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    comment: Python 参数同步
    port: '53106'
  states: {}
- name: nanosdr_source
  id: iio_pluto_source
  parameters:
    bandwidth: bw
    bbdc: 'True'
    buffer_size: '32768'
    comment: 'Pluto 接收: 频点/增益由 XMLRPC 实时控制'
    filter_source: '''Auto'''
    frequency: rx_center_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: sdr_uri1
  states: {}
- name: rx_int_nco
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: '干扰支路 NCO: 干扰频点-RX中心'
    freq: rx_interfere_channel_freq - rx_center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: rx_int_shift
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: 共轭相乘搬移频谱
  states: {}
- name: rx_int_filter
  id: fir_filter_xxx
  parameters:
    comment: 信道低通(随 rx_int_bw 自适应)
    decim: '1'
    taps: rx_int_fir_taps
    type: ccc
  states: {}
- name: rx_int_agc
  id: analog_agc_xx
  parameters:
    comment: 自动增益
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '0.5'
    type: complex
  states: {}
- name: rx_int_quad
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM 鉴频(增益随 rx_int_bw 自适应)
    gain: 1/(2*3.141592653589793*((rx_int_bw/2)-(samp_rate/sps))/samp_rate)
  states: {}
- name: rx_int_rail
  id: analog_rail_ff
  parameters:
    comment: 限幅 ±1.2
    hi: '1.2'
    lo: '-1.2'
  states: {}
- name: rx_int_gauss
  id: fir_filter_xxx
  parameters:
    comment: 高斯匹配滤波
    decim: '1'
    taps: firdes.gaussian(1.0, sps, bt, int(3*sps) + 1)
    type: fff
  states: {}
- name: rx_int_dc_iir
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-8'
    comment: 慢速IIR跟踪直流
    type: float
  states: {}
- name: rx_int_dc_cancel
  id: blocks_sub_xx
  parameters:
    comment: 去直流
    type: float
  states: {}
- name: rx_int_sync
  id: digital_symbol_sync_xx
  parameters:
    comment: 符号同步
    damping: '1.0'
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: rx_int_slicer
  id: digital_binary_slicer_fb
  parameters:
    comment: 二值化
  states: {}
- name: zmq_int_bits_out
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:53104
    comment: 干扰支路 unpacked bits -> Python(53104)
    timeout: '100'
    type: byte
  states: {}
- name: rx_info_nco
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: '信息支路 NCO: 信息频点-RX中心'
    freq: rx_info_channel_freq - rx_center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: rx_info_shift
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: 共轭相乘搬移频谱
  states: {}
- name: rx_info_filter
  id: fir_filter_xxx
  parameters:
    comment: 信息信道低通 270kHz
    decim: '1'
    taps: rx_info_fir_taps
    type: ccc
  states: {}
- name: rx_info_agc2
  id: analog_agc_xx
  parameters:
    comment: 自动增益
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '0.5'
    type: complex
  states: {}
- name: rx_info_quad
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM 鉴频(sens≈1.5628 的倒数)
    gain: 1/(2*3.141592653589793*((rx_info_bw/2)-(samp_rate/sps))/samp_rate)
  states: {}
- name: rx_info_rail
  id: analog_rail_ff
  parameters:
    comment: 限幅 ±1.2
    hi: '1.2'
    lo: '-1.2'
  states: {}
- name: rx_info_gauss
  id: fir_filter_xxx
  parameters:
    comment: 高斯匹配滤波
    decim: '1'
    taps: firdes.gaussian(1.0, sps, bt, int(3*sps) + 1)
    type: fff
  states: {}
- name: rx_info_dc_iir
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-8'
    comment: 慢速IIR跟踪直流
    type: float
  states: {}
- name: rx_info_dc_cancel
  id: blocks_sub_xx
  parameters:
    comment: 去直流
    type: float
  states: {}
- name: rx_info_sync
  id: digital_symbol_sync_xx
  parameters:
    comment: 符号同步
    damping: '1.0'
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: rx_info_slicer
  id: digital_binary_slicer_fb
  parameters:
    comment: 二值化
  states: {}
- name: zmq_info_bits_out
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:53103
    comment: 信息支路 unpacked bits -> Python(53103)
    timeout: '100'
    type: byte
  states: {}
- name: gui_tx_freq
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 发射合成频谱
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: TX spectrum (sum of gated waves)
    type: complex
    ymin: '-120'
  states: {}
- name: gui_int_freq
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 干扰支路频谱
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: RX interfere spectrum
    type: complex
    ymin: '-120'
  states: {}
- name: gui_info_freq
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 信息支路频谱
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: RX info spectrum
    type: complex
    ymin: '-120'
  states: {}
- name: gui_int_demod
  id: qtgui_time_sink_x
  parameters:
    comment: 干扰鉴频波形
    entags: 'False'
    grid: 'True'
    label1: Quad demod
    name: Interfere FM discriminator
    size: Time_Sink_Number*sps
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: gui_int_bits
  id: qtgui_time_sink_x
  parameters:
    comment: 干扰同步比特
    entags: 'False'
    grid: 'True'
    name: Interfere sync output
    size: Time_Sink_Number
    srate: samp_rate/sps
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: gui_info_bits
  id: qtgui_time_sink_x
  parameters:
    comment: 信息同步比特
    entags: 'False'
    grid: 'True'
    name: Info sync output
    size: Time_Sink_Number
    srate: samp_rate/sps
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [zmq_bits_in, '0', tx_mod_info, '0']
- [zmq_bits_in, '0', tx_mod_int1, '0']
- [zmq_bits_in, '0', tx_mod_int2, '0']
- [zmq_bits_in, '0', tx_mod_int3, '0']
- [tx_mod_info, '0', tx_mod_info_gate, '0']
- [tx_mod_int1, '0', tx_mod_int1_gate, '0']
- [tx_mod_int2, '0', tx_mod_int2_gate, '0']
- [tx_mod_int3, '0', tx_mod_int3_gate, '0']
- [tx_mod_info_gate, '0', tx_wave_add, '0']
- [tx_mod_int1_gate, '0', tx_wave_add, '1']
- [tx_mod_int2_gate, '0', tx_wave_add, '2']
- [tx_mod_int3_gate, '0', tx_wave_add, '3']
- [zmq_bits_in_2nd, '0', tx_mod_info_2nd, '0']
- [tx_mod_info_2nd, '0', tx_wave_add, '4']
- [tx_wave_add, '0', nanosdr_sink, '0']
- [tx_wave_add, '0', gui_tx_freq, '0']
- [nanosdr_source, '0', rx_int_shift, '0']
- [nanosdr_source, '0', rx_info_shift, '0']
- [rx_int_nco, '0', rx_int_shift, '1']
- [rx_info_nco, '0', rx_info_shift, '1']
- [rx_int_shift, '0', gui_int_freq, '0']
- [rx_info_shift, '0', gui_info_freq, '0']
- [rx_int_shift, '0', rx_int_filter, '0']
- [rx_int_filter, '0', rx_int_agc, '0']
- [rx_int_agc, '0', rx_int_quad, '0']
- [rx_int_quad, '0', rx_int_rail, '0']
- [rx_int_rail, '0', gui_int_demod, '0']
- [rx_int_rail, '0', rx_int_gauss, '0']
- [rx_int_gauss, '0', rx_int_dc_cancel, '0']
- [rx_int_gauss, '0', rx_int_dc_iir, '0']
- [rx_int_dc_iir, '0', rx_int_dc_cancel, '1']
- [rx_int_dc_cancel, '0', rx_int_sync, '0']
- [rx_int_sync, '0', rx_int_slicer, '0']
- [rx_int_sync, '0', gui_int_bits, '0']
- [rx_int_slicer, '0', zmq_int_bits_out, '0']
- [rx_info_shift, '0', rx_info_filter, '0']
- [rx_info_filter, '0', rx_info_agc2, '0']
- [rx_info_agc2, '0', rx_info_quad, '0']
- [rx_info_quad, '0', rx_info_rail, '0']
- [rx_info_rail, '0', rx_info_gauss, '0']
- [rx_info_gauss, '0', rx_info_dc_cancel, '0']
- [rx_info_gauss, '0', rx_info_dc_iir, '0']
- [rx_info_dc_iir, '0', rx_info_dc_cancel, '1']
- [rx_info_dc_cancel, '0', rx_info_sync, '0']
- [rx_info_sync, '0', rx_info_slicer, '0']
- [rx_info_sync, '0', gui_info_bits, '0']
- [rx_info_slicer, '0', zmq_info_bits_out, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
